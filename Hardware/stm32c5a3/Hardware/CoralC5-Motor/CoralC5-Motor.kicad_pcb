# Repository SmallCoral/c5-car (continued)

## KiCad design Hardware/stm32c5a3/Hardware/CoralC5-Expansion/CoralC5-Expansion.kicad_pcb (continued)

Parts:
C21, C22, C24: 100nF; Capacitor_SMD__C_0603_1608Metric
C23: 10uF / 10V; Capacitor_SMD__C_0603_1608Metric
C25: 1uF / 6.3V; Capacitor_SMD__C_0603_1608Metric
C26: 470pF / C0G; Capacitor_SMD__C_0603_1608Metric
C27: 10nF; Capacitor_SMD__C_0603_1608Metric
C28: 1nF / 2kV; Capacitor_SMD__C_1206_3216Metric
FB1: BLM18AG601SN1D / 600R@100M; Inductor_SMD__L_0603_1608Metric
J3: HR911105A; Connector_RJ__RJ45_Hanrun_HR911105A_Horizontal
R10, R11, R12: 10k / MODE=111; Resistor_SMD__R_0603_1608Metric
R13: 10k / PHYAD0=0; Resistor_SMD__R_0603_1608Metric
R14: 1.5k / MDIO; Resistor_SMD__R_0603_1608Metric
R15: 10k / RESET; Resistor_SMD__R_0603_1608Metric
R16: 10k / IRQ; Resistor_SMD__R_0603_1608Metric
R17, R18, R19, R20: 49.9 / 1%; Resistor_SMD__R_0603_1608Metric
R21, R22: 330; Resistor_SMD__R_0603_1608Metric
R23: 10k / REGOFF=0; Resistor_SMD__R_0603_1608Metric
R24: 10k / INTSEL=1; Resistor_SMD__R_0603_1608Metric
R25: 12.1k / 1%; Resistor_SMD__R_0603_1608Metric
R26: 22 / CLK PHY; Resistor_SMD__R_0603_1608Metric
R27: 22 / CLK MCU; Resistor_SMD__R_0603_1608Metric
R28: 1M / SHIELD BLEED; Resistor_SMD__R_0603_1608Metric
U4: LAN8720A-CP-TR; Package_DFN_QFN__VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_Therm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
Y3: ASE-50.000MHZ-LC-T; Oscillator__Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3V3_ETH: C21.1, C22.1, C23.1, FB1.2, J3.4 (TCT), J3.5 (RCT), R17.1, R18.1, R19.1, R20.1, R22.2, R24.2, U4.1 (VDD2A), U4.19 (VDD1A)
CHASSIS: C28.1, J3.SH (SHIELD), R28.1
GND: C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, J3.8 (CHASSIS), J3.11 (LED1_K), R13.2, R23.2, R25.2, R28.2, U4.25 (VSS), Y3.2 (GND); also elsewhere on the board
unnamed: J3.12 (LED1_A), R21.2
unnamed: J3.9 (LED2_A), R22.1
unnamed: J3.10 (LED2_K), R24.1, U4.2 (LED2/~INTSEL)
unnamed: J3.3 (RD+), R19.2, U4.23 (RXP)
unnamed: J3.6 (RD-), R20.2, U4.22 (RXN)
unnamed: J3.1 (TD+), R17.2, U4.21 (TXP)
unnamed: J3.2 (TD-), R18.2, U4.20 (TXN)
unnamed: R21.1, R23.1, U4.3 (LED1/REGOFF)
unnamed: R25.1, U4.24 (RBIAS)
unnamed: R13.1, U4.10 (RXER/PHYAD0)
unnamed: R26.2, U4.5 (XTAL1/CLKIN)
unnamed: R26.1, R27.1, Y3.3 (OUT)
PA1: R27.2; also elsewhere on the board
PA2: R14.2, U4.12 (MDIO); also elsewhere on the board
PA7: R12.2, U4.11 (CRS_DV/MODE2); also elsewhere on the board
PB12: U4.17 (TXD0); also elsewhere on the board
PB13: U4.16 (TXEN); also elsewhere on the board
PB15: U4.18 (TXD1); also elsewhere on the board
PC1: U4.13 (MDC); also elsewhere on the board
PC4: R10.2, U4.8 (RXD0/MODE0); also elsewhere on the board
PC5: R11.2, U4.7 (RXD1/MODE1); also elsewhere on the board
PE0: R15.2, U4.15 (~RST); also elsewhere on the board
PE1: R16.2, U4.14 (~INT/REFCLKO); also elsewhere on the board
PHY_1V2: C25.1, C26.1, U4.6 (VDDCR)

Notes on the sheet:
LAN8720A，PHY 地址零；自动协商全部十兆与百兆模式
网口无 PoE；八脚按厂商推荐接地，屏蔽壳通过高压电容与泄放电阻接地
外部五十兆时钟分别串联阻尼后送入 PHY 与主控

Parts:
C29: 10uF / 10V; Capacitor_SMD__C_0603_1608Metric
C30: 100nF / 16V; Capacitor_SMD__C_0603_1608Metric
C31: 22uF / 10V; Capacitor_SMD__C_1206_3216Metric
C32: 1uF / EN DELAY; Capacitor_SMD__C_0603_1608Metric
J4: ESP UART / 3V3 LOGIC; Connector_PinHeader_2.54mm__PinHeader_1x06_P2.54mm_Vertical
J5: ESP AUX GPIO; Connector_PinHeader_2.54mm__PinHeader_1x06_P2.54mm_Vertical
J6: ESP FLOW / AT UART; Connector_PinHeader_2.54mm__PinHeader_1x06_P2.54mm_Vertical
R29: 10k / EN; Resistor_SMD__R_0603_1608Metric
R30: 1k / HOST EN; Resistor_SMD__R_0603_1608Metric
R31, R32, R33: 10k / STRAP; Resistor_SMD__R_0603_1608Metric
R34: 1k / HOST BOOT; Resistor_SMD__R_0603_1608Metric
R35, R36: 1k; Resistor_SMD__R_0603_1608Metric
SW3: ESP RESET / SD-1107 / 3x6x2.5; SW_SD1107_2P_6x3_H2.5
SW4: ESP DOWNLOAD / SD-1107 / 3x6x2.5; SW_SD1107_2P_6x3_H2.5
U5: ESP32-C3-MINI-1U-N4X; Espressif__ESP32-C3-MINI-1U

Connections:
ESP_EN: C32.1, J4.5, R29.2, R30.2, SW3.1, U5.8 (EN)
ESP_GPIO0: J5.1, U5.12 (GPIO0)
ESP_GPIO1: J5.2, U5.13 (GPIO1)
ESP_GPIO3: J5.3, U5.6 (GPIO3)
ESP_GPIO4: J6.1, U5.18 (GPIO4_/_AT_RTS)
ESP_GPIO5: J6.2, U5.19 (GPIO5_/_AT_CTS)
ESP_GPIO10: J5.4, U5.16 (GPIO10)
ESP_GPIO18: J5.5, U5.26 (GPIO18_/_USB_D-)
ESP_GPIO19: J5.6, U5.27 (GPIO19_/_USB_D+)
ESP_GPIO20: J4.4, U5.30 (GPIO20_/_U0RXD)
ESP_GPIO21: J4.3, U5.31 (GPIO21_/_U0TXD)
GND: C29.2, C30.2, C31.2, C32.2, J4.2, J6.6, SW3.2, SW4.2, U5.1 (GND), U5.2 (GND), U5.11 (GND), U5.14 (GND), U5.36 (GND), U5.37 (GND), U5.38 (GND), U5.39 (GND), U5.40 (GND), U5.41 (GND), U5.42 (GND), U5.43 (GND), U5.44 (GND), U5.45 (GND), U5.46 (GND), U5.47 (GND), U5.48 (GND), U5.49 (GND), U5.50 (GND), U5.51 (GND), U5.52 (GND), U5.53 (GND); also elsewhere on the board
unnamed: R35.2, U5.20 (GPIO6_/_AT_RX)
unnamed: R36.2, U5.21 (GPIO7_/_AT_TX)
PD3: R30.1; also elsewhere on the board
PD4: R34.1; also elsewhere on the board
PD8: J6.3, R35.1; also elsewhere on the board
PD9: J6.4, R36.1; also elsewhere on the board

Notes on the sheet:
默认使用无硬件流控模式；J6 预留模块的流控信号
无线模块自带 MHF III 天线座，接二点四吉赫兹五十欧天线
MHF III 不兼容常见大号 U.FL 插头；天线通过模块上的连接器接入
主控 USART3 使用 PD8 与 PD9；J4 的 UART0 独立用于下载

Parts:
J8: RIGHT GPIO / 2x24; Connector_PinHeader_2.54mm__PinHeader_2x24_P2.54mm_Vertical
J9: LEFT GPIO / 2x24; Connector_PinHeader_2.54mm__PinHeader_2x24_P2.54mm_Vertical
J12: SWD / JST B4B-XH-A / 2.50mm; Connector_JST__JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical

Connections:
+3V3: J8.44, J8.47, J9.44, J9.47, J12.1; also elsewhere on the board
+5V_SYS: J8.46, J9.46; also elsewhere on the board
GND: J8.45, J8.48, J9.45, J9.48, J12.4; also elsewhere on the board
PA0: J9.41; also elsewhere on the board
PA1: J9.42; also elsewhere on the board
PA2: J9.43; also elsewhere on the board
PA3: J8.43; also elsewhere on the board
PA4: J8.42; also elsewhere on the board
PA5: J8.41; also elsewhere on the board
PA6: J8.40; also elsewhere on the board
PA7: J8.39; also elsewhere on the board
PA8: J8.7; also elsewhere on the board
PA9: J8.6; also elsewhere on the board
PA10: J8.5; also elsewhere on the board
PA11: J8.4; also elsewhere on the board
PA12: J8.3; also elsewhere on the board
PA13: J8.2, J12.2; also elsewhere on the board
PA14: J9.1, J12.3; also elsewhere on the board
PA15: J9.2; also elsewhere on the board
PB0: J8.36; also elsewhere on the board
PB1: J8.35; also elsewhere on the board
PB2: J8.34; also elsewhere on the board
PB3: J9.14; also elsewhere on the board
PB4: J9.15; also elsewhere on the board
PB5: J9.16; also elsewhere on the board
PB6: J9.17; also elsewhere on the board
PB7: J9.18; also elsewhere on the board
PB8: J9.20; also elsewhere on the board
PB9: J9.21; also elsewhere on the board
PB10: J8.24; also elsewhere on the board
PB12: J8.23; also elsewhere on the board
PB13: J8.22; also elsewhere on the board
PB14: J8.21; also elsewhere on the board
PB15: J8.20; also elsewhere on the board
PC0: J9.35; also elsewhere on the board
PC1: J9.36; also elsewhere on the board
PC2: J9.37; also elsewhere on the board
PC3: J9.38; also elsewhere on the board
PC4: J8.38; also elsewhere on the board
PC5: J8.37; also elsewhere on the board
PC6: J8.11; also elsewhere on the board
PC7: J8.10; also elsewhere on the board
PC8: J8.9; also elsewhere on the board
PC9: J8.8; also elsewhere on the board
PC10: J9.3; also elsewhere on the board
PC11: J9.4; also elsewhere on the board
PC12: J9.5; also elsewhere on the board
PC13: J9.30; also elsewhere on the board
PC14: J9.31; also elsewhere on the board
PC15: J9.32; also elsewhere on the board
PD0: J9.6; also elsewhere on the board
PD1: J9.7; also elsewhere on the board
PD2: J9.8; also elsewhere on the board
PD3: J9.9; also elsewhere on the board
PD4: J9.10; also elsewhere on the board
PD5: J9.11; also elsewhere on the board
PD6: J9.12; also elsewhere on the board
PD7: J9.13; also elsewhere on the board
PD8: J8.19; also elsewhere on the board
PD9: J8.18; also elsewhere on the board
PD10: J8.17; also elsewhere on the board
PD11: J8.16; also elsewhere on the board
PD12: J8.15; also elsewhere on the board
PD13: J8.14; also elsewhere on the board
PD14: J8.13; also elsewhere on the board
PD15: J8.12; also elsewhere on the board
PE0: J9.22; also elsewhere on the board
PE1: J9.23; also elsewhere on the board
PE2: J9.24; also elsewhere on the board
PE3: J9.25; also elsewhere on the board
PE4: J9.26; also elsewhere on the board
PE5: J9.27; also elsewhere on the board
PE6: J9.28; also elsewhere on the board
PE7: J8.33; also elsewhere on the board
PE8: J8.32; also elsewhere on the board
PE9: J8.31; also elsewhere on the board
PE10: J8.30; also elsewhere on the board
PE11: J8.29; also elsewhere on the board
PE12: J8.28; also elsewhere on the board
PE13: J8.27; also elsewhere on the board
PE14: J8.26; also elsewhere on the board
PE15: J8.25; also elsewhere on the board
PH2: J9.19; also elsewhere on the board
PH3: J8.1; also elsewhere on the board
PH4: J9.39; also elsewhere on the board
PH5: J9.40; also elsewhere on the board
PH15: J9.29; also elsewhere on the board

Notes on the sheet:
PC14、PC15 直连核心板；J9 的三十三、三十四脚不连接
一脚三点三伏，二脚数据，三脚时钟，四脚地；复位按键在 Core
三点三伏为 Core 电平参考，扩展负载合计不超过一百毫安
两组两列二十四针引出八十四路 GPIO；PH0/PH1 留给 HSE

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
Board: 4 copper layers, 79 parts (0 on the bottom side), 128 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3mm; MountingHole__MountingHole_3mm

File Hardware/stm32c5a3/Hardware/CoralC5-Expansion/docs/BOM.csv (part):

Reference,Value,Footprint,DNP,3D_model
J14,X1611WVS-98-9TV01 / 98P,DevBoard:Streamline_Socket,False,${KIPRJMOD}/Models/Streamline_Socket.step
C35,10uF / 16V X7R,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
C36,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C37,100nF / 50V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C38,22uF / 10V X7R,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
C39,22uF / 10V X7R,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
D1,SS34,DevBoard:Diode_SMD__D_SMC,False,${KIPRJMOD}/Models/D_SMC.step
J1,5V INPUT / 2A,DevBoard:Connector_PinHeader_2.54mm__PinHeader_1x02_P2.54mm_Vertical,False,${KIPRJMOD}/Models/PinHeader_1x02_P2.54mm_Vertical.step
L2,6.8uH / SRN6045TA-6R8M,DevBoard:Inductor_SMD__L_Bourns_SRN6045TA,False,${KIPRJMOD}/Models/L_Bourns_SRN6045TA.step
U6,AP63203WU-7,DevBoard:Package_TO_SOT_SMD__TSOT-23-6,False,${KIPRJMOD}/Models/TSOT-23-6.step
C21,100nF,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C22,100nF,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C23,10uF / 10V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C24,100nF,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C25,1uF / 6.3V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C26,470pF / C0G,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C27,10nF,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C28,1nF / 2kV,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
FB1,BLM18AG601SN1D / 600R@100M,DevBoard:Inductor_SMD__L_0603_1608Metric,False,${KIPRJMOD}/Models/L_0603_1608Metric.step
J3,HR911105A,DevBoard:Connector_RJ__RJ45_Hanrun_HR911105A_Horizontal,False,${KIPRJMOD}/Models/GENERIC_HR911105A_ENVELOPE.wrl
R10,10k / MODE=111,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R11,10k / MODE=111,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R12,10k / MODE=111,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R13,10k / PHYAD0=0,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R14,1.5k / MDIO,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R15,10k / RESET,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R16,10k / IRQ,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R17,49.9 / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R18,49.9 / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R19,49.9 / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R20,49.9 / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R21,330,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R22,330,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R23,10k / REGOFF=0,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R24,10k / INTSEL=1,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R25,12.1k / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R26,22 / CLK PHY,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R27,22 / CLK MCU,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R28,1M / SHIELD BLEED,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
U4,LAN8720A-CP-TR,DevBoard:Package_DFN_QFN__VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_ThermalVias,False,${KIPRJMOD}/Models/GENERIC_LAN8720A_QFN24.wrl
Y3,ASE-50.000MHZ-LC-T,DevBoard:Oscillator__Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm,False,${KIPRJMOD}/Models/GENERIC_ASE_3225.wrl
C29,10uF / 10V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C30,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C31,22uF / 10V,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
C32,1uF / EN DELAY,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
J4,ESP UART / 3V3 LOGIC,DevBoard:Connector_PinHeader_2.54mm__PinHeader_1x06_P2.54mm_Vertical,False,${KIPRJMOD}/Models/PinHeader_1x06_P2.54mm_Vertical.step
J5,ESP AUX GPIO,DevBoard:Connector_PinHeader_2.54mm__PinHeader_1x06_P2.54mm_Vertical,False,${KIPRJMOD}/Models/PinHeader_1x06_P2.54mm_Vertical.step
J6,ESP FLOW / AT UART,DevBoard:Connector_PinHeader_2.54mm__PinHeader_1x06_P2.54mm_Vertical,False,${KIPRJMOD}/Models/PinHeader_1x06_P2.54mm_Vertical.step
R29,10k / EN,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R30,1k / HOST EN,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R31,10k / STRAP,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R32,10k / STRAP,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R33,10k / STRAP,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R34,1k / HOST BOOT,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R35,1k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R36,1k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
SW3,ESP RESET / SD-1107 / 3x6x2.5,DevBoard:SW_SD1107_2P_6x3_H2.5,False,${KIPRJMOD}/Models/GENERIC_SD1107_H2.5.wrl
SW4,ESP DOWNLOAD / SD-1107 / 3x6x2.5,DevBoard:SW_SD1107_2P_6x3_H2.5,False,${KIPRJMOD}/Models/GENERIC_SD1107_H2.5.wrl
U5,ESP32-C3-MINI-1U-N4X,DevBoard:Espressif__ESP32-C3-MINI-1U,False,${KIPRJMOD}/Models/ESP32-C3-MINI-1U.STEP
C33,10uF / 10V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C34,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
J7,Hirose DM3AT-SF-PEJM5,DevBoard:Connector_Card__microSD_HC_Hirose_DM3AT-SF-PEJM5,False,${KIPRJMOD}/Models/microSD_HC_Hirose_DM3AT-SF-PEJM5.step
R37,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R38,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R39,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R40,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R41,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R42,22,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R43,22,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R44,10k / DETECT,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
J8,RIGHT GPIO / 2x24,DevBoard:Connector_PinHeader_2.54mm__PinHeader_2x24_P2.54mm_Vertical,False,${KIPRJMOD}/Models/PinHeader_2x24_P2.54mm_Vertical.step
J9,LEFT GPIO / 2x24,DevBoard:Connector_PinHeader_2.54mm__PinHeader_2x24_P2.54mm_Vertical,False,${KIPRJMOD}/Models/PinHeader_2x24_P2.54mm_Vertical.step
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