# Repository SmallCoral/c5-car (continued)

## KiCad design Hardware/stm32c5a3/Hardware/CoralC5-Core/CoralC5-Core.kicad_pcb (continued)

Parts:
C7: 2.2uF / 6.3V X7R; Capacitor_SMD__C_0603_1608Metric
C8, C9, C10, C11, C12, C15, C16: 100nF / 16V; Capacitor_SMD__C_0603_1608Metric
C13: 4.7uF / 10V; Capacitor_SMD__C_0603_1608Metric
C14: 1uF / 10V; Capacitor_SMD__C_0603_1608Metric
C17, C18: 27pF / C0G; Capacitor_SMD__C_0603_1608Metric
R5: 0 / VREF LINK; Resistor_SMD__R_0603_1608Metric
R6: 10k; Resistor_SMD__R_0603_1608Metric
R7: 10k / BOOT0; Resistor_SMD__R_0603_1608Metric
SW1: RESET / SD-1107 / 3x6x2.5; SW_SD1107_2P_6x3_H2.5
SW2: BOOT0 / SD-1107 / 3x6x2.5; SW_SD1107_2P_6x3_H2.5
U1: STM32C5A3VGT6; Package_QFP__LQFP-100_14x14mm_P0.5mm
Y1: 24MHz / CL18pF; Crystal__Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, R5.1, R6.1, SW2.2, U1.11 (VDD), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, R7.2, SW1.2, U1.10 (VSS), U1.20 (VREF-), U1.27 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), Y1.2 (G), Y1.4 (G); also elsewhere on the board
NRST: C16.1, R6.2, SW1.1, U1.14 (NRST); also elsewhere on the board
unnamed: C7.1, U1.48 (VCAP)
PA0: U1.23 (PA0); also elsewhere on the board
PA1: U1.24 (PA1); also elsewhere on the board
PA2: U1.25 (PA2); also elsewhere on the board
PA3: U1.26 (PA3); also elsewhere on the board
PA4: U1.29 (PA4); also elsewhere on the board
PA5: U1.30 (PA5); also elsewhere on the board
PA6: U1.31 (PA6); also elsewhere on the board
PA7: U1.32 (PA7); also elsewhere on the board
PA8: U1.67 (PA8); also elsewhere on the board
PA9: U1.68 (PA9); also elsewhere on the board
PA10: U1.69 (PA10); also elsewhere on the board
PA11: U1.70 (PA11); also elsewhere on the board
PA12: U1.71 (PA12); also elsewhere on the board
PA13: U1.72 (PA13); also elsewhere on the board
PA14: U1.76 (PA14); also elsewhere on the board
PA15: U1.77 (PA15); also elsewhere on the board
PB0: U1.35 (PB0); also elsewhere on the board
PB1: U1.36 (PB1); also elsewhere on the board
PB2: U1.37 (PB2); also elsewhere on the board
PB3: U1.89 (PB3); also elsewhere on the board
PB4: U1.90 (PB4); also elsewhere on the board
PB5: U1.91 (PB5); also elsewhere on the board
PB6: U1.92 (PB6); also elsewhere on the board
PB7: U1.93 (PB7); also elsewhere on the board
PB8: U1.95 (PB8); also elsewhere on the board
PB9: U1.96 (PB9); also elsewhere on the board
PB10: U1.47 (PB10); also elsewhere on the board
PB12: U1.51 (PB12); also elsewhere on the board
PB13: U1.52 (PB13); also elsewhere on the board
PB14: U1.53 (PB14); also elsewhere on the board
PB15: U1.54 (PB15); also elsewhere on the board
PC0: U1.15 (PC0); also elsewhere on the board
PC1: U1.16 (PC1); also elsewhere on the board
PC2: U1.17 (PC2); also elsewhere on the board
PC3: U1.18 (PC3); also elsewhere on the board
PC4: U1.33 (PC4); also elsewhere on the board
PC5: U1.34 (PC5); also elsewhere on the board
PC6: U1.63 (PC6); also elsewhere on the board
PC7: U1.64 (PC7); also elsewhere on the board
PC8: U1.65 (PC8); also elsewhere on the board
PC9: U1.66 (PC9); also elsewhere on the board
PC10: U1.78 (PC10); also elsewhere on the board
PC11: U1.79 (PC11); also elsewhere on the board
PC12: U1.80 (PC12); also elsewhere on the board
PC13: U1.7 (PC13); also elsewhere on the board
PC14: U1.8 (PC14_/_OSC32_IN); also elsewhere on the board
PC15: U1.9 (PC15_/_OSC32_OUT); also elsewhere on the board
PD0: U1.81 (PD0); also elsewhere on the board
PD1: U1.82 (PD1); also elsewhere on the board
PD2: U1.83 (PD2); also elsewhere on the board
PD3: U1.84 (PD3); also elsewhere on the board
PD4: U1.85 (PD4); also elsewhere on the board
PD5: U1.86 (PD5); also elsewhere on the board
PD6: U1.87 (PD6); also elsewhere on the board
PD7: U1.88 (PD7); also elsewhere on the board
PD8: U1.55 (PD8); also elsewhere on the board
PD9: U1.56 (PD9); also elsewhere on the board
PD10: U1.57 (PD10); also elsewhere on the board
PD11: U1.58 (PD11); also elsewhere on the board
PD12: U1.59 (PD12); also elsewhere on the board
PD13: U1.60 (PD13); also elsewhere on the board
PD14: U1.61 (PD14); also elsewhere on the board
PD15: U1.62 (PD15); also elsewhere on the board
PE0: U1.97 (PE0); also elsewhere on the board
PE1: U1.98 (PE1); also elsewhere on the board
PE2: U1.1 (PE2); also elsewhere on the board
PE3: U1.2 (PE3); also elsewhere on the board
PE4: U1.3 (PE4); also elsewhere on the board
PE5: U1.4 (PE5); also elsewhere on the board
PE6: U1.5 (PE6); also elsewhere on the board
PE7: U1.38 (PE7); also elsewhere on the board
PE8: U1.39 (PE8); also elsewhere on the board
PE9: U1.40 (PE9); also elsewhere on the board
PE10: U1.41 (PE10); also elsewhere on the board
PE11: U1.42 (PE11); also elsewhere on the board
PE12: U1.43 (PE12); also elsewhere on the board
PE13: U1.44 (PE13); also elsewhere on the board
PE14: U1.45 (PE14); also elsewhere on the board
PE15: U1.46 (PE15); also elsewhere on the board
PH0: C17.1, U1.12 (PH0), Y1.1
PH1: C18.1, U1.13 (PH1), Y1.3
PH2: R7.1, SW2.1, U1.94 (PH2_/_BOOT0); also elsewhere on the board
PH3: U1.73 (PH3); also elsewhere on the board
PH4: U1.19 (PH4); also elsewhere on the board
PH5: U1.22 (PH5); also elsewhere on the board
PH15: U1.6 (PH15); also elsewhere on the board
VREF_MCU: C14.1, C15.1, R5.2, U1.21 (VREF+); also elsewhere on the board

Notes on the sheet:
五组供电引脚各配一颗去耦；VCAP 只接电容
已取消 LSE 晶体；PC14/PC15 直连金手指；HSE 负载电容首板测频微调
主控 STM32C5A3VGT6；所有可用 GPIO 均引出至扩展页

Parts:
C1: 100nF / 50V; Capacitor_SMD__C_0603_1608Metric
C2: 10uF / 16V X7R; Capacitor_SMD__C_1206_3216Metric
C3: 100nF / 16V; Capacitor_SMD__C_0603_1608Metric
C4, C5: 22uF / 10V X7R; Capacitor_SMD__C_1206_3216Metric
C6: 1uF / 16V; Capacitor_SMD__C_0603_1608Metric
D2: SS14; Diode_SMD__D_SMA
J2: USB-C / USB2.0 FS; Connector_USB__USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt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
L1: 6.8uH / SRN6045TA-6R8M; Inductor_SMD__L_Bourns_SRN6045TA
R1, R2: 5.1k / 1%; Resistor_SMD__R_0603_1608Metric
R3, R4: 0R; Resistor_SMD__R_0603_1608Metric
R52: 100k / 1%; Resistor_SMD__R_0603_1608Metric
R53: 150k / 1%; Resistor_SMD__R_0603_1608Metric
U2: AP63203WU-7; Package_TO_SOT_SMD__TSOT-23-6
U3: USBLC6-2SC6; Package_TO_SOT_SMD__SOT-23-6

Connections:
+3V3: C4.1, C5.1, L1.2, U2.1 (FB); also elsewhere on the board
+5V_SYS: C2.1, C3.1, D2.1 (K), U2.2 (EN), U2.3 (IN); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), R1.2, R2.2, R53.2, U2.4 (GND), U3.2 (GND); also elsewhere on the board
unnamed: J2.A5 (CC1), R1.1
unnamed: J2.B5 (CC2), R2.1
unnamed: J2.A6 (D+), J2.B6 (D+), U3.3 (I/O2)
unnamed: J2.A7 (D-), J2.B7 (D-), U3.1 (I/O1)
unnamed: R3.1, U3.6 (I/O1)
unnamed: R4.1, U3.4 (I/O2)
unnamed: C1.1, U2.6 (BST)
unnamed: C1.2, L1.1, U2.5 (SW)
PA9: R52.2, R53.1; also elsewhere on the board
PA11: R3.2; also elsewhere on the board
PA12: R4.2; also elsewhere on the board
USB_VBUS: C6.1, D2.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R52.1, U3.5 (VBUS)

Notes on the sheet:
整机主电源接 Expansion；USB 经 D2 供电，仅供低负载调试
输入、输出电容采用较大封装以保留直流偏压后的有效容量
Core 的三点三伏输出只供本板与小负载参考
电感饱和电流大于峰值限流，反馈端直接采样三点三伏
五伏从金手指输入；JP1 已移除，USB 五伏直接接 D2 阳极

Parts:
D3: YELLOW-GREEN; LED_0603_YellowGreen
D4: RED; LED_0603_Red
J13: CORE EDGE / 98P; Streamline_Core_Edge
R49: 10k; Resistor_SMD__R_0603_1608Metric
R50, R51: 1k; Resistor_SMD__R_0603_1608Metric
SW5: USER / PD2 / SD-1107 / 3x6x2.5; SW_SD1107_2P_6x3_H2.5

Connections:
+3V3: J13.A47 (A47_/_+3V3), J13.B47 (B47_/_+3V3), R49.1, R50.1; also elsewhere on the board
+5V_SYS: J13.A48 (A48_/_+5V_SYS), J13.B48 (B48_/_+5V_SYS); also elsewhere on the board
GND: D3.1 (K), D4.1 (K), J13.A1 (A1_/_GND), J13.A49 (A49_/_GND), J13.B1 (B1_/_GND), J13.B49 (B49_/_GND), SW5.2; also elsewhere on the board
NRST: J13.A12 (A12_/_NRST); also elsewhere on the board
unnamed: D3.2 (A), R50.2
unnamed: D4.2 (A), R51.2
PA0: J13.A4 (A4_/_PA0); also elsewhere on the board
PA1: J13.A3 (A3_/_PA1); also elsewhere on the board
PA2: J13.A2 (A2_/_PA2); also elsewhere on the board
PA3: J13.B2 (B2_/_PA3); also elsewhere on the board
PA4: J13.B3 (B3_/_PA4); also elsewhere on the board
PA5: J13.B4 (B4_/_PA5); also elsewhere on the board
PA6: J13.B5 (B5_/_PA6); also elsewhere on the board
PA7: J13.B6 (B6_/_PA7); also elsewhere on the board
PA8: J13.B38 (B38_/_PA8); also elsewhere on the board
PA9: J13.B39 (B39_/_PA9); also elsewhere on the board
PA10: J13.B40 (B40_/_PA10); also elsewhere on the board
PA11: J13.B41 (B41_/_PA11); also elsewhere on the board
PA12: J13.B42 (B42_/_PA12); also elsewhere on the board
PA13: J13.B43 (B43_/_PA13); also elsewhere on the board
PA14: J13.A46 (A46_/_PA14); also elsewhere on the board
PA15: J13.A45 (A45_/_PA15); also elsewhere on the board
PB0: J13.B9 (B9_/_PB0); also elsewhere on the board
PB1: J13.B10 (B10_/_PB1); also elsewhere on the board
PB2: J13.B11 (B11_/_PB2); also elsewhere on the board
PB3: J13.A33 (A33_/_PB3); also elsewhere on the board
PB4: J13.A32 (A32_/_PB4); also elsewhere on the board
PB5: J13.A31 (A31_/_PB5); also elsewhere on the board
PB6: J13.A30 (A30_/_PB6); also elsewhere on the board
PB7: J13.A29 (A29_/_PB7); also elsewhere on the board
PB8: J13.A27 (A27_/_PB8); also elsewhere on the board
PB9: J13.A26 (A26_/_PB9); also elsewhere on the board
PB10: J13.B21 (B21_/_PB10); also elsewhere on the board
PB12: J13.B22 (B22_/_PB12); also elsewhere on the board
PB13: J13.B23 (B23_/_PB13); also elsewhere on the board
PB14: J13.B24 (B24_/_PB14); also elsewhere on the board
PB15: J13.B25 (B25_/_PB15); also elsewhere on the board
PC0: J13.A11 (A11_/_PC0); also elsewhere on the board
PC1: J13.A10 (A10_/_PC1); also elsewhere on the board
PC2: J13.A9 (A9_/_PC2); also elsewhere on the board
PC3: J13.A8 (A8_/_PC3); also elsewhere on the board
PC4: J13.B7 (B7_/_PC4); also elsewhere on the board
PC5: J13.B8 (B8_/_PC5); also elsewhere on the board
PC6: J13.B34 (B34_/_PC6); also elsewhere on the board
PC7: J13.B35 (B35_/_PC7); also elsewhere on the board
PC8: J13.B36 (B36_/_PC8); also elsewhere on the board
PC9: J13.B37 (B37_/_PC9); also elsewhere on the board
PC10: J13.A44 (A44_/_PC10); also elsewhere on the board
PC11: J13.A43 (A43_/_PC11); also elsewhere on the board
PC12: J13.A42 (A42_/_PC12); also elsewhere on the board
PC13: J13.A17 (A17_/_PC13); also elsewhere on the board
PC14: J13.A16 (A16_/_PC14); also elsewhere on the board
PC15: J13.A15 (A15_/_PC15); also elsewhere on the board
PD0: J13.A41 (A41_/_PD0); also elsewhere on the board
PD1: J13.A40 (A40_/_PD1); also elsewhere on the board
PD2: J13.A39 (A39_/_PD2), R49.2, SW5.1; also elsewhere on the board
PD3: J13.A38 (A38_/_PD3); also elsewhere on the board
PD4: J13.A37 (A37_/_PD4); also elsewhere on the board
PD5: J13.A36 (A36_/_PD5); also elsewhere on the board
PD6: J13.A35 (A35_/_PD6); also elsewhere on the board
PD7: J13.A34 (A34_/_PD7); also elsewhere on the board
PD8: J13.B26 (B26_/_PD8); also elsewhere on the board
PD9: J13.B27 (B27_/_PD9); also elsewhere on the board
PD10: J13.B28 (B28_/_PD10); also elsewhere on the board
PD11: J13.B29 (B29_/_PD11); also elsewhere on the board
PD12: J13.B30 (B30_/_PD12); also elsewhere on the board
PD13: J13.B31 (B31_/_PD13); also elsewhere on the board
PD14: J13.B32 (B32_/_PD14); also elsewhere on the board
PD15: J13.B33 (B33_/_PD15); also elsewhere on the board
PE0: J13.A25 (A25_/_PE0); also elsewhere on the board
PE1: J13.A24 (A24_/_PE1); also elsewhere on the board
PE2: J13.A23 (A23_/_PE2); also elsewhere on the board
PE3: J13.A22 (A22_/_PE3), R51.1; also elsewhere on the board
PE4: J13.A21 (A21_/_PE4); also elsewhere on the board
PE5: J13.A20 (A20_/_PE5); also elsewhere on the board
PE6: J13.A19 (A19_/_PE6); also elsewhere on the board
PE7: J13.B12 (B12_/_PE7); also elsewhere on the board
PE8: J13.B13 (B13_/_PE8); also elsewhere on the board
PE9: J13.B14 (B14_/_PE9); also elsewhere on the board
PE10: J13.B15 (B15_/_PE10); also elsewhere on the board
PE11: J13.B16 (B16_/_PE11); also elsewhere on the board
PE12: J13.B17 (B17_/_PE12); also elsewhere on the board
PE13: J13.B18 (B18_/_PE13); also elsewhere on the board
PE14: J13.B19 (B19_/_PE14); also elsewhere on the board
PE15: J13.B20 (B20_/_PE15); also elsewhere on the board
PH2: J13.A28 (A28_/_PH2); also elsewhere on the board
PH3: J13.B44 (B44_/_PH3); also elsewhere on the board
PH4: J13.A7 (A7_/_PH4); also elsewhere on the board
PH5: J13.A5 (A5_/_PH5); also elsewhere on the board
PH15: J13.A18 (A18_/_PH15); also elsewhere on the board
VREF_MCU: J13.A6 (A6_/_VREF_MCU); also elsewhere on the board

Notes on the sheet:
PH0/PH1 仅接 HSE；PC14/PC15 直连金手指
四线 XH 调试座位于 Expansion；Core 调试测试点已移除
Coral-C5 自定义针序；A 背面接 MCU 上半，B 正面接 MCU 下半；严禁插入电脑插槽
