# Repository SmallCoral/c5-car (continued)

## KiCad design Hardware/stm32c5a3/Hardware/CoralC5-Core/CoralC5-Core.kicad_pcb (continued)

Board: 2 copper layers, 70.0 x 51.5 mm, 44 parts (0 on the bottom side), 103 nets.

Other parts of the board:
LOGO1: SmallCoral; Logo_SmallCoral_11mm

File Hardware/stm32c5a3/Hardware/CoralC5-Core/docs/BOM.csv:

Reference,Value,Footprint,DNP,3D_model
C1,100nF / 50V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C2,10uF / 16V X7R,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
C3,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C4,22uF / 10V X7R,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
C5,22uF / 10V X7R,DevBoard:Capacitor_SMD__C_1206_3216Metric,False,${KIPRJMOD}/Models/C_1206_3216Metric.step
C6,1uF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
D2,SS14,DevBoard:Diode_SMD__D_SMA,False,${KIPRJMOD}/Models/D_SMA.step
J2,USB-C / USB2.0 FS,DevBoard:Connector_USB__USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,False,${KIPRJMOD}/Models/USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal.step
L1,6.8uH / SRN6045TA-6R8M,DevBoard:Inductor_SMD__L_Bourns_SRN6045TA,False,${KIPRJMOD}/Models/L_Bourns_SRN6045TA.step
R1,5.1k / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R2,5.1k / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R3,0R,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R4,0R,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R52,100k / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R53,150k / 1%,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
U2,AP63203WU-7,DevBoard:Package_TO_SOT_SMD__TSOT-23-6,False,${KIPRJMOD}/Models/TSOT-23-6.step
U3,USBLC6-2SC6,DevBoard:Package_TO_SOT_SMD__SOT-23-6,False,${KIPRJMOD}/Models/SOT-23-6.step
C7,2.2uF / 6.3V X7R,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C8,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C9,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C10,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C11,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C12,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C13,4.7uF / 10V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C14,1uF / 10V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C15,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C16,100nF / 16V,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C17,27pF / C0G,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
C18,27pF / C0G,DevBoard:Capacitor_SMD__C_0603_1608Metric,False,${KIPRJMOD}/Models/C_0603_1608Metric.step
R5,0 / VREF LINK,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R6,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R7,10k / BOOT0,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
SW1,RESET / SD-1107 / 3x6x2.5,DevBoard:SW_SD1107_2P_6x3_H2.5,False,${KIPRJMOD}/Models/GENERIC_SD1107_H2.5.wrl
SW2,BOOT0 / SD-1107 / 3x6x2.5,DevBoard:SW_SD1107_2P_6x3_H2.5,False,${KIPRJMOD}/Models/GENERIC_SD1107_H2.5.wrl
U1,STM32C5A3VGT6,DevBoard:Package_QFP__LQFP-100_14x14mm_P0.5mm,False,${KIPRJMOD}/Models/LQFP-100_14x14mm_P0.5mm.step
Y1,24MHz / CL18pF,DevBoard:Crystal__Crystal_SMD_3225-4Pin_3.2x2.5mm,False,${KIPRJMOD}/Models/Crystal_SMD_3225-4Pin_3.2x2.5mm.step
D3,YELLOW-GREEN,DevBoard:LED_0603_YellowGreen,False,${KIPRJMOD}/Models/LED_0603_YellowGreen.step
D4,RED,DevBoard:LED_0603_Red,False,${KIPRJMOD}/Models/LED_0603_Red.step
R49,10k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R50,1k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
R51,1k,DevBoard:Resistor_SMD__R_0603_1608Metric,False,${KIPRJMOD}/Models/R_0603_1608Metric.step
SW5,USER / PD2 / SD-1107 / 3x6x2.5,DevBoard:SW_SD1107_2P_6x3_H2.5,False,${KIPRJMOD}/Models/GENERIC_SD1107_H2.5.wrl

## KiCad design Hardware/stm32c5a3/Hardware/CoralC5-Expansion/CoralC5-Expansion.kicad_pcb

File Hardware/stm32c5a3/Hardware/CoralC5-Expansion/README.md:

# CoralC5-Expansion

用 KiCad 10 打开 CoralC5-Expansion.kicad_pro。这是 Coral-C5 的单槽扩展板，顶部 J14 接核心板，左右 J9、J8 各一组 2×24 排针，下方放 RJ45 和 microSD，右侧放 ESP32-C3-MINI-1U。100×86mm 板框为本项目暂定尺寸。

板上包括 LAN8720A 百兆网口及 50MHz 时钟、SPI3 microSD、带 MHF III 外置天线座的 Wi-Fi／Bluetooth LE 模块、5V 入口和独立 AP63203 降压。J1 输入稳压 5V、2A，U6 的 +3V3_EXP 给本板外设供电；金手指和排针上的 +3V3 来自 Core，外接负载预算合计 100mA，两路输出不并联。J14 已同步 C5-EDGE-3 自定义针序，须与同版 Core 配对。J9 的 31、32 脚直接连接 Core 的 PC14、PC15，33、34 脚不连接；PH0、PH1 留在 Core 晶振回路。其余排针顺序保持原样，共引出 84 路 GPIO。

J12 是四线 SWD，JST XH 2.50mm，顺序固定为 1 脚 3V3／VTref、2 脚 SWDIO、3 脚 SWCLK、4 脚 GND。TP5 为 NRST，TP6 为 VREF_MCU。SW3、SW4 是 ESP 复位和下载按键，已改为两脚 3×6×2.5 贴片款，参考 SD-1107 图纸，本体实际 6.1×3.6mm、高 2.5mm。

本板有七页原理图，见 [电路 PDF](docs/CoralC5-Expansion_Schematic.pdf)，排针与金手指对应关系放在 [header_pinout.csv](docs/header_pinout.csv)，元件清单在 [BOM.csv](docs/BOM.csv)。73 个采购位号均绑定本地模型，其中 U4、J3、Y3 和两个按键使用通用外形，两个测试点不需要采购模型。

ERC 为 0 错误、0 警告，PCB 与原理图一致性检查为 0。PCB 尚未布线，有 314 个未连接项；J14 的 51 号固定焊盘到定位孔只有 0.05mm，低于当前 0.25mm 规则，需按母座原厂推荐焊盘复核修订。当前文件不作为制板发布版，接口边界和待处理项目见 [共同说明](../Shared/interface.md)。

2026 年 10 月 23 日全检确认当前电路与主控接口对应，PCB 仍未布线。PHY、无线和 SD 卡的部分去耦电容离电源脚约 7～16mm，需要在布线前重排。详细距离和全检结果见 [双板检查记录](../Shared/full_review_2026-10-23.md)。

Notes on the sheet:
SPI3 用于卡座，USART3 用于无线；四线 SWD 保留既定顺序
Core 输出逻辑参考；外设稳压由本板 U6 提供
单槽扩展板、百兆网口、无线与存储

Parts:
C33: 10uF / 10V; Capacitor_SMD__C_0603_1608Metric
C34: 100nF / 16V; Capacitor_SMD__C_0603_1608Metric
J7: Hirose DM3AT-SF-PEJM5; Connector_Card__microSD_HC_Hirose_DM3AT-SF-PEJM5
R37, R38, R39, R40, R41: 10k; Resistor_SMD__R_0603_1608Metric
R42, R43: 22; Resistor_SMD__R_0603_1608Metric
R44: 10k / DETECT; Resistor_SMD__R_0603_1608Metric

Connections:
/SPI 模式 microSD 存储接口/SD_DAT1: J7.8 (DAT1), R41.2
/SPI 模式 microSD 存储接口/SD_DAT2: J7.1 (DAT2), R37.2
/SPI 模式 microSD 存储接口/SD_DI: J7.3 (CMD), R39.2, R42.2
GND: C33.2, C34.2, J7.6 (VSS), J7.9 (DET_B), J7.SH (SHIELD); also elsewhere on the board
unnamed: J7.5 (CLK), R43.2
PA15: J7.2 (DAT3/CD), R38.2; also elsewhere on the board
PC10: R43.1; also elsewhere on the board
PC11: J7.7 (DAT0), R40.2; also elsewhere on the board
PC12: R42.1; also elsewhere on the board
PH4: J7.10 (DET_A), R44.2; also elsewhere on the board

Notes on the sheet:
CMD 与全部数据线保留上拉；未使用的数据线不接地
主控 SPI3，三点三伏供电；不支持 SDMMC 四位总线
未配置独立电源开关，固件应在插拔后重新初始化文件系统
卡检测低电平表示插卡；初始化时钟不超过四百千赫兹

Parts:
J14: X1611WVS-98-9TV01 / 98P; Streamline_Socket
TP5: NRST; TestPoint__TestPoint_Pad_D1.0mm
TP6: VREF_MCU; TestPoint__TestPoint_Pad_D1.0mm

Connections:
+3V3: J14.A47 (A47_/_+3V3), J14.B47 (B47_/_+3V3); also elsewhere on the board
+5V_SYS: J14.A48 (A48_/_+5V_SYS), J14.B48 (B48_/_+5V_SYS); also elsewhere on the board
GND: J14.50 (MP1_/_GND), J14.51 (MP2_/_GND), J14.A1 (A1_/_GND), J14.A49 (A49_/_GND), J14.B1 (B1_/_GND), J14.B49 (B49_/_GND); also elsewhere on the board
NRST: J14.A12 (A12_/_NRST), TP5.1
PA0: J14.A4 (A4_/_PA0); also elsewhere on the board
PA1: J14.A3 (A3_/_PA1); also elsewhere on the board
PA2: J14.A2 (A2_/_PA2); also elsewhere on the board
PA3: J14.B2 (B2_/_PA3); also elsewhere on the board
PA4: J14.B3 (B3_/_PA4); also elsewhere on the board
PA5: J14.B4 (B4_/_PA5); also elsewhere on the board
PA6: J14.B5 (B5_/_PA6); also elsewhere on the board
PA7: J14.B6 (B6_/_PA7); also elsewhere on the board
PA8: J14.B38 (B38_/_PA8); also elsewhere on the board
PA9: J14.B39 (B39_/_PA9); also elsewhere on the board
PA10: J14.B40 (B40_/_PA10); also elsewhere on the board
PA11: J14.B41 (B41_/_PA11); also elsewhere on the board
PA12: J14.B42 (B42_/_PA12); also elsewhere on the board
PA13: J14.B43 (B43_/_PA13); also elsewhere on the board
PA14: J14.A46 (A46_/_PA14); also elsewhere on the board
PA15: J14.A45 (A45_/_PA15); also elsewhere on the board
PB0: J14.B9 (B9_/_PB0); also elsewhere on the board
PB1: J14.B10 (B10_/_PB1); also elsewhere on the board
PB2: J14.B11 (B11_/_PB2); also elsewhere on the board
PB3: J14.A33 (A33_/_PB3); also elsewhere on the board
PB4: J14.A32 (A32_/_PB4); also elsewhere on the board
PB5: J14.A31 (A31_/_PB5); also elsewhere on the board
PB6: J14.A30 (A30_/_PB6); also elsewhere on the board
PB7: J14.A29 (A29_/_PB7); also elsewhere on the board
PB8: J14.A27 (A27_/_PB8); also elsewhere on the board
PB9: J14.A26 (A26_/_PB9); also elsewhere on the board
PB10: J14.B21 (B21_/_PB10); also elsewhere on the board
PB12: J14.B22 (B22_/_PB12); also elsewhere on the board
PB13: J14.B23 (B23_/_PB13); also elsewhere on the board
PB14: J14.B24 (B24_/_PB14); also elsewhere on the board
PB15: J14.B25 (B25_/_PB15); also elsewhere on the board
PC0: J14.A11 (A11_/_PC0); also elsewhere on the board
PC1: J14.A10 (A10_/_PC1); also elsewhere on the board
PC2: J14.A9 (A9_/_PC2); also elsewhere on the board
PC3: J14.A8 (A8_/_PC3); also elsewhere on the board
PC4: J14.B7 (B7_/_PC4); also elsewhere on the board
PC5: J14.B8 (B8_/_PC5); also elsewhere on the board
PC6: J14.B34 (B34_/_PC6); also elsewhere on the board
PC7: J14.B35 (B35_/_PC7); also elsewhere on the board
PC8: J14.B36 (B36_/_PC8); also elsewhere on the board
PC9: J14.B37 (B37_/_PC9); also elsewhere on the board
PC10: J14.A44 (A44_/_PC10); also elsewhere on the board
PC11: J14.A43 (A43_/_PC11); also elsewhere on the board
PC12: J14.A42 (A42_/_PC12); also elsewhere on the board
PC13: J14.A17 (A17_/_PC13); also elsewhere on the board
PC14: J14.A16 (A16_/_PC14); also elsewhere on the board
PC15: J14.A15 (A15_/_PC15); also elsewhere on the board
PD0: J14.A41 (A41_/_PD0); also elsewhere on the board
PD1: J14.A40 (A40_/_PD1); also elsewhere on the board
PD2: J14.A39 (A39_/_PD2); also elsewhere on the board
PD3: J14.A38 (A38_/_PD3); also elsewhere on the board
PD4: J14.A37 (A37_/_PD4); also elsewhere on the board
PD5: J14.A36 (A36_/_PD5); also elsewhere on the board
PD6: J14.A35 (A35_/_PD6); also elsewhere on the board
PD7: J14.A34 (A34_/_PD7); also elsewhere on the board
PD8: J14.B26 (B26_/_PD8); also elsewhere on the board
PD9: J14.B27 (B27_/_PD9); also elsewhere on the board
PD10: J14.B28 (B28_/_PD10); also elsewhere on the board
PD11: J14.B29 (B29_/_PD11); also elsewhere on the board
PD12: J14.B30 (B30_/_PD12); also elsewhere on the board
PD13: J14.B31 (B31_/_PD13); also elsewhere on the board
PD14: J14.B32 (B32_/_PD14); also elsewhere on the board
PD15: J14.B33 (B33_/_PD15); also elsewhere on the board
PE0: J14.A25 (A25_/_PE0); also elsewhere on the board
PE1: J14.A24 (A24_/_PE1); also elsewhere on the board
PE2: J14.A23 (A23_/_PE2); also elsewhere on the board
PE3: J14.A22 (A22_/_PE3); also elsewhere on the board
PE4: J14.A21 (A21_/_PE4); also elsewhere on the board
PE5: J14.A20 (A20_/_PE5); also elsewhere on the board
PE6: J14.A19 (A19_/_PE6); also elsewhere on the board
PE7: J14.B12 (B12_/_PE7); also elsewhere on the board
PE8: J14.B13 (B13_/_PE8); also elsewhere on the board
PE9: J14.B14 (B14_/_PE9); also elsewhere on the board
PE10: J14.B15 (B15_/_PE10); also elsewhere on the board
PE11: J14.B16 (B16_/_PE11); also elsewhere on the board
PE12: J14.B17 (B17_/_PE12); also elsewhere on the board
PE13: J14.B18 (B18_/_PE13); also elsewhere on the board
PE14: J14.B19 (B19_/_PE14); also elsewhere on the board
PE15: J14.B20 (B20_/_PE15); also elsewhere on the board
PH2: J14.A28 (A28_/_PH2); also elsewhere on the board
PH3: J14.B44 (B44_/_PH3); also elsewhere on the board
PH4: J14.A7 (A7_/_PH4); also elsewhere on the board
PH5: J14.A5 (A5_/_PH5); also elsewhere on the board
PH15: J14.A18 (A18_/_PH15); also elsewhere on the board
VREF_MCU: J14.A6 (A6_/_VREF_MCU), TP6.1

Notes on the sheet:
Coral-C5 自定义针序；A 背面接 MCU 上半，B 正面接 MCU 下半；严禁插入电脑插槽
板载外设使用独立三点三伏稳压，不与 Core 稳压输出并联
三点三伏触点由 Core 提供，供调试电平参考及小负载扩展

Parts:
C35: 10uF / 16V X7R; Capacitor_SMD__C_1206_3216Metric
C36: 100nF / 16V; Capacitor_SMD__C_0603_1608Metric
C37: 100nF / 50V; Capacitor_SMD__C_0603_1608Metric
C38, C39: 22uF / 10V X7R; Capacitor_SMD__C_1206_3216Metric
D1: SS34; Diode_SMD__D_SMC
J1: 5V INPUT / 2A; Connector_PinHeader_2.54mm__PinHeader_1x02_P2.54mm_Vertical
L2: 6.8uH / SRN6045TA-6R8M; Inductor_SMD__L_Bourns_SRN6045TA
U6: AP63203WU-7; Package_TO_SOT_SMD__TSOT-23-6

Connections:
+5V_SYS: C35.1, C36.1, D1.1 (K), U6.2 (EN), U6.3 (IN); also elsewhere on the board
GND: C35.2, C36.2, C38.2, C39.2, J1.2, U6.4 (GND); also elsewhere on the board
unnamed: D1.2 (A), J1.1
unnamed: C37.1, U6.6 (BST)
unnamed: C37.2, L2.1, U6.5 (SW)

Notes on the sheet:
五伏两安从 J1 输入，Core 与 Expansion 分别稳压
仅支持断电插拔；USB 跳帽供电时按低负载使用
金手指三点三伏与本板三点三伏为独立网络，禁止并联
