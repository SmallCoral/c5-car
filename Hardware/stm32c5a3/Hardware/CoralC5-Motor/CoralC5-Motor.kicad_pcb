# Repository SmallCoral/c5-car

File README.md:

# Coral-C5 · 循线小车与钢球稳控装置

**嵌念万花 · 2026 校赛 A 题 · 已结项**

小车沿黑线行驶，同时让球槽里的钢球停在指定位置。前置八路灰度探头检测赛道，编码器测量左右轮速。MaixCAM2 上报球心，STM32C5A3 控制闭环步进电机，通过曲柄连杆改变球槽倾角。

| 要找的内容 | 入口 |
| --- | --- |
| 读代码、构建固件、操作比赛菜单 | [STM32 C/LL 主控](Firmware/README.md) · [MaixCAM2 识别程序](Firmware/26h/README.md) · [ESP32 语音桥](Firmware/voice/xiaosai.py) |
| 打开电路板、接线或查采购型号 | [三个 KiCad 工程](Hardware/stm32c5a3/README.md) · [实车接线](Documentation/reference/m2-interfaces.md) · [器件选型与采购](Documentation/reference/parts-selection.md) |
| 看整车实物与装配 | [作品图集](Images/README.md#整车与装配) · [设计报告](Documentation/design-report.docx) |
| 查赛题、测量结果或版本 | [基本说明](Documentation/README.md) · [比赛实测](Documentation/validation/README.md) · [最终固件校验值](Firmware/releases/README.md) |

最终实车回读为 **`A9898F82`**，应用长 69,224 字节。第一题依次稳到 O、右 5 cm、左 5 cm。第二题、第四题和发挥一回到 A 点时按黑线标记停车，第三题从 A 到 B 直行 1.5 m，按里程停车。最终版的实车停车误差尚未尺量。

原始比赛视频、提交包和整理前的工程材料可从[结项快照](https://github.com/SmallCoral/c5-car/tree/1b936e16e70845d13a9f0e41dbcd20ecfca4ad00)取回。

## KiCad design Hardware/stm32c5a3/Hardware/CoralC5-Motor/CoralC5-Motor.kicad_pcb

File Hardware/stm32c5a3/Hardware/CoralC5-Motor/README.md:

# CoralC5-Motor

## 当前状态

整理于 2026-11-21。
当前电路为 M2.8P2，用户已完成 Core/Motor 焊接，轮电机、编码器、Emm 步进、彩屏按键和蓝牙已进入实物联调；使用方法见[固件入口](../../../../Firmware/README.md)。

11 月 21 日在当前设计副本上导出原生网表，Motor ERC 无报项。PCB 原生 DRC 有 17 条错误、6 条警告，另有 6 条原理图一致性警告，未连接项为 0。资源检查 957 项中 4 项失败。原工程保留手工布局。[核验方法与边界](https://github.com/SmallCoral/c5-car/blob/1b936e16e70845d13a9f0e41dbcd20ecfca4ad00/Documentation/validation/2026-11-21-handoff.md) · [本次原始结果](docs/handoff-2026-11-21/snapshot.json) · [11 月 10 日历史复查](https://github.com/SmallCoral/c5-car/blob/1b936e16e70845d13a9f0e41dbcd20ecfca4ad00/Documentation/validation/2026-11-10-motor-pcb-review.md)

| 内容 | 入口 |
| --- | --- |
| 编辑工程 | [KiCad 工程](CoralC5-Motor.kicad_pro)、[原理图](CoralC5-Motor.kicad_sch)、[PCB](CoralC5-Motor.kicad_pcb) |
| 查看图纸 | [十页原理图 PDF](docs/CoralC5-Motor_Schematic.pdf) |
| 采购 | [完整 BOM、精简 RC 和降本候选](docs/bom/README.md) |
| 电气定义 | [外接接口](../../../../Documentation/reference/m2-interfaces.md)、[GPIO 分配](../../../../Documentation/reference/motor-core-pins.md) |
| 原始 PCB 检查 | [DRC](https://github.com/SmallCoral/c5-car/blob/1b936e16e70845d13a9f0e41dbcd20ecfca4ad00/Hardware/stm32c5a3/Hardware/CoralC5-Motor/docs/pcb-review-2026-11-10/drc-refill.json)、[同步核对](https://github.com/SmallCoral/c5-car/blob/1b936e16e70845d13a9f0e41dbcd20ecfca4ad00/Hardware/stm32c5a3/Hardware/CoralC5-Motor/docs/pcb-review-2026-11-10/verify-pcb-sync.json)、[摘要](https://github.com/SmallCoral/c5-car/blob/1b936e16e70845d13a9f0e41dbcd20ecfca4ad00/Hardware/stm32c5a3/Hardware/CoralC5-Motor/docs/pcb-review-2026-11-10/review-summary.json) |
| 历史检查 | [验证索引](../../../../Documentation/validation/README.md) |

三份 XLSX 均为采购快照，不自动更新原理图或 PCB 中的料号。
精简表省略的阻容仍属于设计，降本替换仍须核对引脚、封装及外围。

## 修改与检查

继续在本目录的原生工程上编辑，保留本地库、位号、UUID 和手工布局。修改原理图后导出网表，运行 KiCad ERC 和 `tools/verify_schematic.py`。修改 PCB 后单独运行原生 DRC 及 `tools/verify_pcb_sync.py`。安装孔、模型精度与采购料号各有独立依据。[模型来源](Models/README.md) · [接线与保护边界](../../../../Documentation/reference/m2-interfaces.md)

Board: 2 copper layers, 100.0 x 100.0 mm, 146 parts (0 on the bottom side), 106 nets.

Parts:
C1, C13, C33: 470u / 25V; Capacitor_THT__CP_Radial_D10.0mm_P5.00mm
C2, C84: 10uF/50V X5R; Capacitor_SMD__C_0805_2012Metric
C3, C72, C82: 100nF/50V; C_0603_1608Metric_Gap0.85mm_HandSolder
C4: 100nF/16V; C_0603_1608Metric_Gap0.85mm_HandSolder
C5, C50, C86, C88: 22uF/25V X7R; Capacitor_SMD__C_1210_3225Metric
C10, C30: 22n / 50V; C_0603_1608Metric_Gap0.85mm_HandSolder
C11, C14, C16, C19, C31, C34, C36, C39: 100n / 16V; C_0603_1608Metric_Gap0.85mm_HandSolder
C12, C32: 100n / 50V; C_0603_1608Metric_Gap0.85mm_HandSolder
C15, C35: 10n / 16V; C_0603_1608Metric_Gap0.85mm_HandSolder
C17, C18, C37, C38: 1n / 16V; C_0603_1608Metric_Gap0.85mm_HandSolder
C20, C40: 1u / 10V; C_0603_1608Metric_Gap0.85mm_HandSolder
C54, C55: 1uF/10V X7R; C_0603_1608Metric_Gap0.85mm_HandSolder
C56: 100nF/10V; C_0603_1608Metric_Gap0.85mm_HandSolder
C62, C78: 10uF/10V; Capacitor_SMD__C_0805_2012Metric
C63, C89: 470pF/50V C0G; C_0603_1608Metric_Gap0.85mm_HandSolder
C74, C75, C85, C87, C93: 100nF/50V X7R; C_0603_1608Metric_Gap0.85mm_HandSolder
C81, C92: 150uF/16V; Capacitor_SMD__CP_Elec_10x7.9
C83: 10uF/10V X7R; Capacitor_SMD__C_0805_2012Metric
C90, C91: 10nF/50V X7R; C_0603_1608Metric_Gap0.85mm_HandSolder
C94: 10uF/25V X5R; Capacitor_SMD__C_0805_2012Metric
D1: BZT52C12; Diode_SMD__D_SOD-123
D2: SMAJ15A; Diode_SMD__D_SMA
D3: SS34; Diode_SMD__D_SMA
D4: LED_GREEN; LED_0603_1608Metric_Gap0.85mm_HandSolder
F1: 15A/85V FAST; Fuse_Littelfuse_448_6.10x2.69mm_GenericBody
H1, H1#2, H1#3, H1#5: 安装孔 M3 D3.2; MountingHole__MountingHole_3.2mm_M3
H1#4, H2: TFT孔 D2.0; MountingHole__MountingHole_2mm
J1: XT60PW-M; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J4, J6: MG513 / XH2.50 / 6P; Connector_JST__JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J8: SWD / XH2.50; Connector_JST__JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J10: RUN / STOP_NC; Connector_PinHeader_2.54mm__PinHeader_1x02_P2.54mm_Vertical
J14: C5-EDGE-3 / 98P; C5_EDGE_3_Socket
J15: HC-08_四脚接口; Connector_PinSocket_2.54mm__PinSocket_1x04_P2.54mm_Vertical
J17: TFT_ZJY180S0800TG01; Connector_PinSocket_2.54mm__PinSocket_1x08_P2.54mm_Vertical
J18: LicheePi4A_2x06; Connector_PinHeader_2.54mm__PinHeader_2x06_P2.54mm_Vertical
J19: MaixCAM2_6P; ZX_MX1.25_6PWT
J20: 灰度并行_CH1-CH8; Connector_JST__JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J21: 灰度电源_GND+5V; Connector_JST__JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J23: ZDT_XS_TTL_8P; Connector_JST__JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J25: LicheePi4A_USB_C_5V; Connector_USB__USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_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
J28: Action4_USB_C_5V; Connector_USB__USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_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
L1, L2: 3.3uH / 12A; Inductor_SMD__L_Wuerth_HCI-1050
Q1, Q2: DMP3007LK3-13; Package_TO_SOT_SMD__TO-252-2
R1, R14, R34, R73, R79: 100k; R_0603_1608Metric_Gap0.85mm_HandSolder
R2: 4.7k; R_0603_1608Metric_Gap0.85mm_HandSolder
R3, R61: 82k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R4, R10, R11, R30, R31, R62: 10k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R5: 2.2k; R_0603_1608Metric_Gap0.85mm_HandSolder
R6: 100R; R_0603_1608Metric_Gap0.85mm_HandSolder
R7, R13, R18, R19, R33, R38, R39, R50, R51, R52, R53, R55, R56: 10k; R_0603_1608Metric_Gap0.85mm_HandSolder
R12, R32: 1.82k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R15, R16, R17, R35, R36, R37: 1k; R_0603_1608Metric_Gap0.85mm_HandSolder
R59, R64: 53.6k / 0.1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R60, R65: 10k / 0.1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R63, R92: 200k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R66, R67: 15.8k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R72: 95.3k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
R91, R93: 100k / 1%; R_0603_1608Metric_Gap0.85mm_HandSolder
SW1: SS12D10G5; SS12D10G5_SHOUHAN_3P_P4.80mm
SW2: 模式; SW_Push_6x6x4.3mm_SMD_4Pad_Generic
SW3: 下一项; SW_Push_6x6x4.3mm_SMD_4Pad_Generic
SW4: 确认; SW_Push_6x6x4.3mm_SMD_4Pad_Generic
SW5: 启动; SW_Push_6x6x4.3mm_SMD_4Pad_Generic
U1, U6: AP64500SP-13; Diodes_SO8EP_AP64500
U2, U4: DRV8874PWPR; DRV8874_PWP0016
U3, U5: SN74LVC2G17DCKR; Package_TO_SOT_SMD__SOT-363_SC-70-6
U7: AP2112K-3.3TRG1; Package_TO_SOT_SMD__SOT-23-5
U8, U16: TPS25810RVCR; Package_DFN_QFN__Texas_RVC0020A_WQFN-20-1EP_3x4mm_P0.5mm_EP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
U10: SGM2531CXPS8G/TR; SGM_PS8_SOIC8_EP2.33x3.22_HandSolder
U11: SN74LV1T125DBVR; Package_TO_SOT_SMD__SOT-23-5
U12: SN74LVC1G125DBVR; Package_TO_SOT_SMD__SOT-23-5

Connections:
/V3V3: C19.1, C20.1, C39.1, C40.1, C74.1, C75.1, J4.2 (VENC), J6.2 (VENC), J8.1, J14.A47 (A47_/_+3V3), J14.B47 (B47_/_+3V3), R10.1, R13.2, R18.1, R19.2, R30.1, R33.2, R38.1, R39.2, R50.1, R51.1, R52.1, R53.1, R73.1, R79.1, U3.5 (VCC), U5.5 (VCC), U11.5 (VCC), U12.5 (VCC)
/V3V3_EXT: C55.1, C56.1, J15.1 (3V3), J17.2 (VCC_3V3), R55.1, R56.1, U7.5 (VOUT)
/V5_CAM: C72.1, C78.1, C81.1, C82.1, C88.1, L2.2, R64.1, U10.3 (ENUV), U10.4 (IN), U16.2 (IN1), U16.3 (IN1), U16.4 (IN2), U16.5 (AUX), U16.6 (EN), U16.7 (CHG), U16.8 (CHG_HI)
/V5_EXT: C5.1, C54.1, C92.1, C93.1, D3.2 (A), J21.2 (+5V), L1.2, R59.1, U7.1 (VIN), U7.3 (EN), U8.2 (IN1), U8.3 (IN1), U8.4 (IN2), U8.5 (AUX), U8.6 (EN), U8.7 (CHG), U8.8 (CHG_HI)
/V5_SYS: D3.1 (K), J14.A48 (A48_/_+5V_SYS), J14.B48 (B48_/_+5V_SYS), R5.1
/VM: C1.1, C2.1, C3.1, C11.1, C12.1, C13.1, C31.1, C32.1, C33.1, C50.1, C84.1, C85.1, C86.1, D2.1 (K), J23.1 (VM_V+), Q2.2 (D), R3.1, R61.1, U1.2 (VIN), U2.11 (VM), U4.11 (VM), U6.2 (VIN)
/中景园屏幕与四个操作按钮/KEY_MODE: J14.B33 (B33_/_PD15), R50.2, SW2.1
/中景园屏幕与四个操作按钮/KEY_NEXT: J14.B38 (B38_/_PA8), R51.2, SW3.1
/中景园屏幕与四个操作按钮/KEY_OK: J14.B40 (B40_/_PA10), R52.2, SW4.1
/中景园屏幕与四个操作按钮/KEY_START: J14.B44 (B44_/_PH3), R53.2, SW5.1
/中景园屏幕与四个操作按钮/TFT_BL: J14.B3 (B3_/_PA4), J17.8 (BL)
/中景园屏幕与四个操作按钮/TFT_CS: J14.B7 (B7_/_PC4), J17.7 (CS), R55.2
/中景园屏幕与四个操作按钮/TFT_DC: J14.B8 (B8_/_PC5), J17.6 (DC)
/中景园屏幕与四个操作按钮/TFT_MOSI: J14.B11 (B11_/_PB2), J17.4 (SDA)
/中景园屏幕与四个操作按钮/TFT_RES: J14.B9 (B9_/_PB0), J17.5 (RES), R56.2
/中景园屏幕与四个操作按钮/TFT_SCK: J14.B10 (B10_/_PB1), J17.3 (SCL)
/右电机与编码器/MOTOR_RUN: J10.2, R7.1, R14.1, R34.1, U2.3 (nSLEEP), U4.3 (nSLEEP)
/右电机与编码器/R_DIR: J14.A43 (A43_/_PC11), U4.2 (PH/IN2)
/右电机与编码器/R_ENC_A: J14.A33 (A33_/_PB3), U5.6 (1Y)
/右电机与编码器/R_ENC_B: J14.A45 (A45_/_PA15), U5.4 (2Y)
/右电机与编码器/R_ISENSE: C36.1, J14.A11 (A11_/_PC0), R35.2
/右电机与编码器/R_M_OUT1: J6.6 (M+), U4.8 (OUT1)
/右电机与编码器/R_M_OUT2: J6.1 (M-), U4.10 (OUT2)
/右电机与编码器/R_PWM: J14.A30 (A30_/_PB6), U4.1 (EN/IN1)
/右电机与编码器/R_nFAULT: J14.A44 (A44_/_PC10), R33.1, U4.4 (nFAULT)
/四脚蓝牙与外接步进驱动接口/BT_RX: J14.B6 (B6_/_PA7), J15.4 (TXD)
/四脚蓝牙与外接步进驱动接口/BT_TX: J14.B5 (B5_/_PA6), J15.3 (RXD)
/四脚蓝牙与外接步进驱动接口/STEP_UART_RX: J14.B35 (B35_/_PC7), J23.8 (T/B/L_TX)
/四脚蓝牙与外接步进驱动接口/STEP_UART_TX: J14.B34 (B34_/_PC6), J23.7 (R/A/H_RX)
/左电机与编码器/L_DIR: J14.A8 (A8_/_PC3), U2.2 (PH/IN2)
/左电机与编码器/L_ENC_A: J14.A4 (A4_/_PA0), U3.6 (1Y)
/左电机与编码器/L_ENC_B: J14.A3 (A3_/_PA1), U3.4 (2Y)
/左电机与编码器/L_ISENSE: C16.1, J14.A5 (A5_/_PH5), R15.2
/左电机与编码器/L_M_OUT1: J4.6 (M+), U2.8 (OUT1)
/左电机与编码器/L_M_OUT2: J4.1 (M-), U2.10 (OUT2)
/左电机与编码器/L_PWM: J14.A9 (A9_/_PC2), U2.1 (EN/IN1)
/左电机与编码器/L_nFAULT: J14.A7 (A7_/_PH4), R13.1, U2.4 (nFAULT)
/核心板接口/GRAY_CH1: J14.B12 (B12_/_PE7), J20.1 (CH1)
/核心板接口/GRAY_CH2: J14.B13 (B13_/_PE8), J20.2 (CH2)
/核心板接口/GRAY_CH3: J14.B14 (B14_/_PE9), J20.3 (CH3)
/核心板接口/GRAY_CH4: J14.B15 (B15_/_PE10), J20.4 (CH4)
/核心板接口/GRAY_CH5: J14.B16 (B16_/_PE11), J20.5 (CH5)
/核心板接口/GRAY_CH6: J14.B17 (B17_/_PE12), J20.6 (CH6)
/核心板接口/GRAY_CH7: J14.B18 (B18_/_PE13), J20.7 (CH7)
/核心板接口/GRAY_CH8: J14.B19 (B19_/_PE14), J20.8 (CH8)
/核心板接口/LICHEE_RX: J14.A27 (A27_/_PB8), R79.2, U11.4 (Y)
/核心板接口/LICHEE_TX: J14.A26 (A26_/_PB9), R73.2, U12.2 (A)
/核心板接口/MOTOR_EN_REQ: J14.B2 (B2_/_PA3), R6.1
/核心板接口/SWCLK: J8.3, J14.A46 (A46_/_PA14)
/核心板接口/SWDIO: J8.2, J14.B43 (B43_/_PA13)
/核心板接口/VIDEO_RX: J14.B22 (B22_/_PB12), J19.5 (UART4_TX)
/核心板接口/VIDEO_TX: J14.B23 (B23_/_PB13), J19.6 (UART4_RX)
/灰度与 MaixCAM2 识别/V5_MAIX_PROT: C62.1, J19.2 (5V_IN), U10.5 (OUT)
/输入、总开关与降压/SW_SOURCE: D1.1 (K), Q1.3 (S), Q2.3 (S), R1.2, SW1.1 (A)
GND: C1.2, C2.2, C3.2, C5.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C19.2, C20.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.1, C38.2, C39.2, C40.2, C50.2, C54.2, C55.2, C56.2, C62.2, C63.2, C72.2, C74.2, C75.2, C78.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, D2.2 (A), D4.1 (K), J1.2 (GND), J4.5 (GND), J6.5 (GND), J8.4, J14.50 (MP1_/_GND), J14.51 (MP2_/_GND), J14.A1 (A1_/_GND), J14.A49 (A49_/_GND), J14.B1 (B1_/_GND), J14.B49 (B49_/_GND), J15.2 (GND), J17.1 (GND), J18.3 (GND), J18.4 (GND), J19.1 (GND), J19.MP, J21.1 (GND), J23.2 (GND), J25.A12 (GND), J25.B12 (GND), J25.SH (SHIELD), J28.A12 (GND), J28.B12 (GND), J28.SH (SHIELD), R2.2, R4.2, R7.2, R11.2, R12.2, R14.2, R31.2, R32.2, R34.2, R60.2, R62.2, R63.2, R65.2, R72.2, R92.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.7 (GND), U1.9 (EP_GND), U2.7 (IMODE), U2.9 (PGND), U2.15 (GND), U2.16 (PMODE), U2.17 (EP), U3.2 (GND), U4.7 (IMODE), U4.9 (PGND), U4.15 (GND), U4.16 (PMODE), U4.17 (EP), U5.2 (GND), U6.7 (GND), U6.9 (EP_GND), U7.2 (GND), U8.12 (GND), U8.21 (EP_GND), U10.1 (GND), U10.8 (OVP), U10.9 (EP_GND), U11.1 (nOE), U11.3 (GND), U12.1 (nOE), U12.3 (GND), U16.12 (GND), U16.21 (EP_GND)
unnamed: C83.1, J28.A9 (VBUS), J28.B9 (VBUS), U16.14 (OUT), U16.15 (OUT)
unnamed: C90.1, R66.2
unnamed: C91.1, R67.2
unnamed: C94.1, J25.A9 (VBUS), J25.B9 (VBUS), U8.14 (OUT), U8.15 (OUT)
unnamed: D1.2 (A), Q1.1 (G), Q2.1 (G), R1.1, SW1.2 (B)
unnamed: D4.2 (A), R5.2
unnamed: F1.1, J1.1 (BAT+)
unnamed: J4.3 (A), R16.1, R18.2
unnamed: J4.4 (B), R17.1, R19.1
unnamed: J6.3 (A), R36.1, R38.2
unnamed: J6.4 (B), R37.1, R39.1
unnamed: J10.1, R6.2
unnamed: J18.11 (UART1_RX_3V3), U12.4 (Y)
unnamed: J18.12 (UART1_TX_1V8), U11.2 (A)
unnamed: J25.A5 (CC1), U8.11 (CC1)
unnamed: J25.B5 (CC2), U8.13 (CC2)
unnamed: J28.A5 (CC1), U16.11 (CC1)
unnamed: J28.B5 (CC2), U16.13 (CC2)
unnamed: F1.2, Q1.2 (D)
unnamed: R2.1, SW1.3 (C)
unnamed: C4.1, U1.1 (BST)
unnamed: C63.1, R67.1, U1.6 (COMP)
unnamed: R3.2, R4.1, U1.3 (EN)
unnamed: R59.2, R60.1, U1.5 (FB)
unnamed: R92.1, U1.4 (RT_CLK)
unnamed: C4.2, L1.1, U1.8 (SW)
unnamed: C10.1, U2.13 (CPH)
unnamed: C10.2, U2.14 (CPL)
unnamed: C15.1, R12.1, R15.1, U2.6 (IPROPI)
unnamed: C11.2, U2.12 (VCP)
unnamed: C14.1, R10.2, R11.1, U2.5 (VREF)
unnamed: C17.2, R16.2, U3.1 (1A)
unnamed: C18.1, R17.2, U3.3 (2A)
unnamed: C30.1, U4.13 (CPH)
unnamed: C30.2, U4.14 (CPL)
unnamed: C35.1, R32.1, R35.1, U4.6 (IPROPI)
unnamed: C31.2, U4.12 (VCP)
unnamed: C34.1, R30.2, R31.1, U4.5 (VREF)
unnamed: C37.2, R36.2, U5.1 (1A)
unnamed: C38.1, R37.2, U5.3 (2A)
unnamed: C87.1, U6.1 (BST)
unnamed: C89.1, R66.1, U6.6 (COMP)
unnamed: R61.2, R62.1, U6.3 (EN)
unnamed: R64.2, R65.1, U6.5 (FB)
unnamed: R63.1, U6.4 (RT_CLK)
unnamed: C87.2, L2.1, U6.8 (SW)
unnamed: R93.1, U8.10 (REF)
unnamed: R93.2, U8.9 (REF_RTN)
unnamed: R72.1, U10.7 (ILIM)
unnamed: R91.1, U16.10 (REF)
unnamed: R91.2, U16.9 (REF_RTN)

File Hardware/stm32c5a3/Hardware/CoralC5-Motor/docs/BOM.csv (part):

reference,value,mpn,lcsc,tolerance,footprint,datasheet,sheet,purchase_url,stock_checked,stock,price_cny_default_tier,procurement_status,status
C1,470u / 25V,EEU-FR1E471,,,Motor:Capacitor_THT__CP_Radial_D10.0mm_P5.00mm,,/输入、总开关与降压/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C10,22n / 50V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C11,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C12,100n / 50V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C13,470u / 25V,EEU-FR1E471,,,Motor:Capacitor_THT__CP_Radial_D10.0mm_P5.00mm,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C14,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C15,10n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C16,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C17,1n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C18,1n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C19,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C2,10uF/50V X5R,GRM21BR61H106KE43L,,,Motor:Capacitor_SMD__C_0805_2012Metric,,/输入、总开关与降压/,https://item.szlcsc.com/439567.html,2026-11-07,193410,0.568,domestic in-stock snapshot; recheck before ordering,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C20,1u / 10V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/左电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C3,100nF/50V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/输入、总开关与降压/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C30,22n / 50V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C31,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C32,100n / 50V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C33,470u / 25V,EEU-FR1E471,,,Motor:Capacitor_THT__CP_Radial_D10.0mm_P5.00mm,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C34,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C35,10n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C36,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C37,1n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C38,1n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C39,100n / 16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C4,100nF/16V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/输入、总开关与降压/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C40,1u / 10V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/右电机与编码器/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C5,22uF/25V X7R,GRM32ER71E226KE15L,C21397,,Motor:Capacitor_SMD__C_1210_3225Metric,,/输入、总开关与降压/,https://item.szlcsc.com/22114.html,2026-11-07,52241,1.15,domestic in-stock snapshot; recheck before ordering,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C50,22uF/25V X7R,GRM32ER71E226KE15L,C21397,,Motor:Capacitor_SMD__C_1210_3225Metric,,/输入、总开关与降压/,https://item.szlcsc.com/22114.html,2026-11-07,52241,1.15,domestic in-stock snapshot; recheck before ordering,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C54,1uF/10V X7R,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/共享五伏的 USB-C 与三伏三/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C55,1uF/10V X7R,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/共享五伏的 USB-C 与三伏三/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C56,100nF/10V,,,,Motor:C_0603_1608Metric_Gap0.85mm_HandSolder,,/中景园屏幕与四个操作按钮/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
C62,10uF/10V,,,,Motor:Capacitor_SMD__C_0805_2012Metric,,/灰度与 MaixCAM2 识别/,,,,,legacy selection; current domestic availability not audited,M2.8 schematic/PCB component draft; routing DRC FAIL; physical untested; not production BOM
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
## KiCad design Hardware/stm32c5a3/Hardware/CoralC5-Core/CoralC5-Core.kicad_pcb

File Hardware/stm32c5a3/Hardware/CoralC5-Core/README.md:

# CoralC5-Core

用 KiCad 10 打开 CoralC5-Core.kicad_pro。本板保留 STM32C5A3VGT6 最小系统、24MHz HSE 晶体、独立 3.3V 降压、USB-C、复位与 BOOT、用户按键和两颗 LED，当前通过 J13 金手指与 Motor 底板配套。历史 Expansion 方案不在当前仓库；配套接口以 [98 触点合同](../Shared/interface.csv)为准。

2026-11-16 已完成焊接后的外设联调和无线升级，入口见[LL 固件](../../../../Firmware/README.md)。下文带日期的硬件检查保留当时结论，不能替代最新文件或实物的重新验证。

正面丝印已补上 RESET、BOOT0 和 USER，用户按键接 PD2。左侧空白处放了从 Coral-Wave 沿用的珊瑚 Logo，下方署名 Designed by SmallCoral。图案转换成 11mm 单色轮廓，封装和来源放在 [Logo 说明](../Shared/branding/README.md)，可在 KiCad 中整组移动。

核心板已改为 1.60mm 双层板，只保留 F.Cu 和 B.Cu。原先两个内层没有走线或铜皮，已按用户要求删除；顶底层已有布线、通孔和器件摆放保留。

过孔间距按嘉立创双层 FR4、1oz 常规打样配置。过孔铜环到其他铜为 0.15mm，孔到铜及过孔孔边距为 0.20mm，有铜插件孔参与的孔边距保留 0.45mm。具体来源及适用条件见 [打样规则](docs/fabrication_rules.md)。复制工程时也要带上 CoralC5-Core.kicad_dru。

板形与接点直接沿用固定版本的 Streamline SL_BOARD，外框为 70.00×51.45mm。初始摆放参考 [H562 实物照片](https://stm32world.com/wiki/Streamline_MCU_STM32H562)，此后由用户继续调整和布线。MCU 保持 −45°，24MHz 晶体在主控左上，VREF 滤波集中在左侧，五颗 VDD 去耦分别对应各组电源脚，VCAP 电容留在下方。降压电源、USB-C、ESD 和供电二极管位于右侧，最新位置见下图。

照片中的 H562 使用 AMS1117，我们保留 AP63203 与电感，电源区按降压回路集中摆放。D3 是黄绿色电源灯，D4 是红色用户灯，PE3 高电平点亮。SW1、SW2、SW5 已统一改为两脚 3×6×2.5 贴片款，按 SD-1107 图纸绘制，实际本体 6.1×3.6mm，需与现有按键脚距核对。照片用于估计功能区域，具体走线和晶体回路仍需后续布局布线时复核。

SWD 由金手指引出至配套底板，当前 Motor 的调试接口见[接口表](../../../../Documentation/reference/m2-interfaces.md)。当前保存的 Core 已移除 TP1 至 TP4，单独调试需从金手指或对应网络接线。BOOT0 保留 C5A3 的 PH2。Y2 及 C19、C20 已移除，当前没有外部 LSE 晶体。R45 至 R48 也已从原理图和 PCB 删除，PC14、PC15 直接连接 A16、A15；PH0、PH1 仅接 HSE，A14、A13 标为不连接。C5-EDGE-3 为自定义电气针序，除这两个空位外，信号顺序沿用 MCU 当前摆放对应的正面 B 排和背面 A 排。配套底板须使用同步的 98 触点合同。

本板有四页原理图，见 [电路 PDF](docs/CoralC5-Core_Schematic.pdf)，元件清单在 [BOM.csv](docs/BOM.csv)，采购工作簿与选型依据在[采购目录](docs/bom)。42 个采购位号均绑定本地模型，三个开关模型为标明来源的通用外形；J13 金手指属于板本身。JP1 已移除，USB_VBUS 直接接 D2 阳极，D2 保留反灌隔离；USB 供电仍仅用于低负载调试。

2026 年 10 月 23 日按用户最新要求保留 USB 的 R3、R4，均改为 0R，原理图与 PCB 一致。两颗电阻保留原来的 0603 封装、位置与布线，U3.6 经 R3 接 PA11，U3.4 经 R4 接 PA12。PCB 中已无先前临时添加的跨层走线和两个过孔，本次只修改这两个 PCB 阻值字段，其他走线、过孔、摆放和铜区均保持用户最新保存版本。0R 用作连接跳线；[DS15137 Rev3 第 5.3.28 节表 71 注 2](https://www.st.com/resource/en/datasheet/stm32c5a3vg.pdf#page=109)说明 USB 驱动片内已包含匹配阻抗。

2026 年 10 月 23 日复查结果为 ERC 0 错误、0 警告，原理图与 PCB 一致性问题为 0，308 个编号焊盘与最新网表一致。双板连通性和资源检查通过 2019 项，无失败项。这些检查不代表制板 DRC 已通过。

2026 年 10 月 24 日复查用户提交 88247a1，三条重叠线段已移除。Core 当前为 0 个 DRC 错误、0 个警告、0 个未连接项，一致性问题为 0。B49 地铜已接通，J2 地焊盘圆角半径 0.30mm 的修正仍保留，孔到铜约为 0.233mm。处理记录和原位置图见 [PCB 复查记录](docs/pcb_review.md)。C7 的 2.2µF／6.3V 标注仍低于 C5A3 对 VCAP 电容至少 10V 的要求，还需核对 3MHz 时小于 20mΩ 的 ESR。原厂条款和检查边界见 [双板全检记录](../Shared/full_review_2026-10-23.md)。

Notes on the sheet:
MCU、晶体、复位、USB、电源及状态灯保留在 Core
STM32C5A3 金手指核心板
四线 SWD 座在 Expansion；主控仍为 C5A3，不照搬 C551 启动与时钟电路
金手指自定义针序；MCU 下半接正面 B 排，上半接背面 A 排

## Code that names these connections

File Documentation/diagrams/build_motor_interface_tree.py (part):

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   ('U2 / U4：DRV8874；VENC 当前取 Core 3.3V',26),
   ('M−、M+ 均为 H 桥输出；M− 不是系统地',26)]),
  dict(y=1160,h=350,title='ZDT_XS TTL 一体步进套件',tag='J23 · XH 8P',refs=['J23'],intro='仅接 1 / 2 / 7 / 8；不直接连接电机线圈',pins=['VM_STEP','GND','NC','NC','NC','NC','模块 RX','模块 TX'],lines=[
   ('7 RX ← PB6 / USART1_TX；8 TX → PB7 / RX',26),
   ('VM → F2 4A → Q6/Q7 电源开关 → 1 脚',26),
   ('PD12 / B30 高电平供电，硬件默认断电',26),
   ('U15 串口隔离；启动稳定后再发送命令',26)])]),
 dict(id='03',title='调试与停机',sub='SWD / 轮电机使能',color='#596C85',soft='#EBF0F6',side='L',cy=1820,cards=[
  dict(y=1570,h=230,title='SWD 下载与调试',tag='J8 · XH 4P',refs=['J8'],pins=['3V3','SWDIO','SWCLK','GND'],lines=[
   ('3V3 为 Core 电源参考；与调试器共地',26)]),
  dict(y=1830,h=220,title='左右轮 RUN / STOP 跳帽',tag='J10 · 2P',refs=['J10'],lines=[
   ('1：MOTOR_EN_REQ 经 R6；2：MOTOR_RUN',27),
   ('插帽：允许 PE8 控制左右轮驱动',27),
   ('拔帽：下拉 MOTOR_RUN，左右轮进入休眠',26),
   ('只控制轮驱动，不控制步进或整车总电源',26)])]),
 dict(id='04',title='视觉系统',sub='MaixCAM2 识别 / Action 4 图传',color='#8155C8',soft='#F0EBFB',side='R',cy=557,cards=[
  dict(y=250,h=350,title='MaixCAM2 · 钢球识别',tag='J19 · J27',refs=['J19','J27'],intro='J19：MX1.25 / 6P · 保护后 5V · USART6',pins=['GND','5V','NC','NC','模块 TX','模块 RX'],lines=[
   ('5 TX → PC7 / RX；6 RX ← PC6 / TX',26),
   ('J27：1=5V，2=EN_FEED；短接使能，带电 USB 前拔帽',26),
   ('保留过压、限流、软启动和防反灌',26),
   ('六针座额定 1A，识别叠加充电须实测',26)]),
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   ('U16 TPS25810；无 PD/PPS，不接 MCU 数据',26)])]),
 dict(id='05',title='灰度循迹',sub='感为 8 路 + MSPM0L1306 辅助板',color='#178D7B',soft='#E7F6F1',side='R',cy=1105,cards=[
  dict(y=970,h=310,title='底部八路灰度组件',tag='J20 · J21',refs=['J20','J21'],intro='J20：XH / 8P 数字信号口，按 1～8 脚排列',pins=['CH1','CH2','CH3','CH4','CH5','CH6','CH7','CH8'],lines=[
   ('CH1～6 → PE10～15；CH7/8 → PD10/11',26),
   ('J21：XH / 2P；1 GND，2 总 5V',26),
   ('两口一起接；GPIO 无上下拉；KEY/Err/CLK/DAT 不接',25)])]),
 dict(id='06',title='显示与操作',sub='TFT / HC-08 / 四个按键',color='#BB4778',soft='#FCEBF2',side='R',cy=1790,cards=[
  dict(y=1370,h=310,title='TFT 任务显示屏',tag='J17 · 排母 8P',refs=['J17'],intro='2.54mm 排母 · 外设 LDO 3.3V · SPI1',pins=['GND','3V3','SCL','SDA','RES','DC','CS','BL'],lines=[
   ('SCL=SCK / PA5；SDA=MOSI / PA7',26),
   ('RES=PB0；DC=PB1；CS=PA4；BL=PB4',26),
   ('H1/H2：两个 D2.0 安装孔，孔距须实物复核',26)]),
  dict(y=1710,h=240,title='HC-08 蓝牙模块',tag='J15 · 排母 4P',refs=['J15'],intro='2.54mm 排母 · 固定外设 3.3V',pins=['3V3','GND','模块 RXD','模块 TXD'],lines=[
   ('3 RXD ← PA2 / TX；4 TXD → PA3 / RX',26)]),
  dict(y=1980,h=230,title='四个板载操作按键',tag='SW2～SW5',refs=[],lines=[
   ('SW2 模式 PC4；SW3 下一项 PC5',27),
   ('SW4 确认 PB2；SW5 启动 PE7',27),
   ('6×6×4.3mm 贴片；低有效，10k 上拉、软件消抖',26)])])]

# 列出所有实物接头，包括辅助控制和调试排针。
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
File Hardware/stm32c5a3/Hardware/CoralC5-Motor/tools/verify_functional_pinout.py:

"""把模块信号沿 Core 接口追踪到 LQFP100 物理引脚和 ST 复用功能格。"""
from pathlib import Path
import csv
import json
import re
import xml.etree.ElementTree as ET

ROOT = Path(__file__).resolve().parents[1]
DOC = ROOT / 'docs'
SHARED = ROOT.parent / 'Shared'
RESERVED = {'PA9', 'PA11', 'PA12', 'PA13', 'PA14', 'PH2', 'PE3', 'PD2'}

# 从网表建立引脚到网络分组的索引。
def pin_groups(path):
    result = {}
    for net in ET.parse(path).findall('.//nets/net'):
        members = {n.get('ref') + ':' + n.get('pin') for n in net.findall('node')}
        for member in members:
            result[member] = members
    return result

# 沿板间接口追踪 GPIO 和复用功能并生成逐项结果。
def audit():
    plan = json.loads((DOC / 'layout-pinplan.json').read_text(encoding='utf8'))['plan']
    primary = json.loads((DOC / 'sources/pinplan-st-table14.json').read_text(encoding='utf8'))
    contract = {r['contact']: r for r in csv.DictReader((SHARED / 'interface.csv').open(encoding='utf-8-sig'))}
    motor = pin_groups(DOC / 'netlist.xml')
    core = pin_groups(DOC / 'core_netlist.xml')
    text = (SHARED / 'sources/DS15137_STM32C5Axxx_Datasheet_Rev3.pdf.txt').read_text(encoding='utf8')
    checks = []
    rows = []

    # 登记功能核对结果及其证据。
    def ck(name, ok, detail=None):
        checks.append({'name': name, 'pass': bool(ok), 'detail': detail})

    ck('39 unique module signals, contacts and GPIOs', len(plan) == len({r['signal'] for r in plan}) == len({r['contact'] for r in plan}) == len({r['gpio'] for r in plan}) == 39)
    ck('Core USB, SWD, boot and board functions reserved', not RESERVED & {r['gpio'] for r in plan})
    for contact, c in contract.items():
        if c['gpio'] and c['mcu_pin']:
            ck(contact + ' fixed package pin matches DS15137 Table13 LQFP100', primary['lqfp100_pins_from_local_rev3_table13'].get(c['gpio']) == int(c['mcu_pin']))
            ck(contact + ' Core native net reaches actual MCU pin', 'U1:' + c['mcu_pin'] in core.get('J13:' + contact, set()))
    for r in plan:
        c = contract[r['contact']]
        prefix = r['signal'] + ': '
        ck(prefix + 'contact maps to selected GPIO', c['gpio'] == r['gpio'])
        ck(prefix + 'native Motor net reaches module endpoint', r['endpoint'] in motor.get('J14:' + r['contact'], set()))
        # 除触点名称外，还要检查该 GPIO 是否已被 Core 板上电路占用。
        ck(prefix + 'Core GPIO is a dedicated passthrough', core.get('J13:' + r['contact']) == {'J13:' + r['contact'], 'U1:' + c['mcu_pin']})
        cell = ''
        if r['af'] is not None:
            cell = primary['af_cells'][r['gpio']][r['af']]
            ck(prefix + 'function occurs in independent ST HTML AF cell', re.search(r'(?<![A-Z0-9_])' + re.escape(r['function']) + r'(?![A-Z0-9_])', cell) is not None, {'gpio': r['gpio'], 'af': r['af'], 'cell': cell})
        if r['function'].startswith('ADC'):
            blocks = [b for b in text.split('\n\n') if re.search(r'\b' + r['gpio'] + r'\b[^\n]*\bI/O\b', b)]
            ck(prefix + 'ADC instance and channel occur in Table13', any(re.search(r'\b' + r['function'] + r'\b', b) for b in blocks))
        if r['function'].startswith('EXTI'):
            ck(prefix + 'EXTI line equals GPIO pin index', r['function'] == 'EXTI' + re.search(r'\d+', r['gpio'])[0])
        rows.append({'signal': r['signal'], 'endpoint': r['endpoint'], 'contact': r['contact'], 'gpio': r['gpio'], 'mcu_lqfp100_pin': c['mcu_pin'], 'function': r['function'], 'af': r['af'], 'st_table14_cell': cell})
    by_name = {r['signal']: r for r in plan}
    serials = []
    for name, tx, rx in [('Bluetooth', 'BT_TX', 'BT_RX'), ('MaixCAM2', 'VIDEO_TX', 'VIDEO_RX'), ('stepper', 'STEP_UART_TX', 'STEP_UART_RX'), ('Lichee', 'LICHEE_TX', 'LICHEE_RX')]:
        a, b = by_name[tx]['function'], by_name[rx]['function']
        ck(name + ' has matching hardware TX/RX on one peripheral', a.endswith('_TX') and b == a[:-2] + 'RX')
        serials.append(a.split('_')[0])
    ck('four serial devices use independent peripherals', len(set(serials)) == 4)
    sck, mosi = by_name['TFT_SCK']['function'], by_name['TFT_MOSI']['function']
    ck('TFT clock and MOSI use the same SPI peripheral', sck.endswith('_SCK') and mosi == sck[:-3] + 'MOSI')
    counters = []
    for side in ['L', 'R']:
        functions = [by_name[side + '_ENC_' + phase]['function'] for phase in ['A', 'B']]
        parsed = [re.fullmatch(r'(TIM[123458])_CH([12])', f) for f in functions]
        ok = all(parsed) and parsed[0][1] == parsed[1][1] and {p[2] for p in parsed} == {'1', '2'}
        ck(side + ' encoder uses CH1/CH2 of an encoder-capable timer', ok)
        if ok:
            counters.append(parsed[0][1])
    pwm = [by_name[side + '_PWM']['function'] for side in ['L', 'R']]
    ck('wheel PWM uses separate channels of one timer', pwm[0].split('_')[0] == pwm[1].split('_')[0] and pwm[0] != pwm[1])
    counters.extend([pwm[0].split('_')[0], by_name['TFT_BL']['function'].split('_')[0]])
    ck('both encoders, wheel PWM and backlight have independent counters', len(set(counters)) == 4)
    ck('motor fault EXTI lines do not conflict', by_name['L_nFAULT']['function'] != by_name['R_nFAULT']['function'])
    ck('eight grayscale inputs stay on PE7 through PE14', [by_name['GRAY_CH' + str(i)]['gpio'] for i in range(1, 9)] == ['PE' + str(i) for i in range(7, 15)])
    report = {'date': '2026-11-08', 'pass': all(c['pass'] for c in checks), 'checks': len(checks), 'failed': [c for c in checks if not c['pass']], 'source': primary['source_url'], 'source_sha256': primary['source_sha256'], 'rows': rows, 'results': checks, 'scope': 'Schematic functional pinout only; firmware setup, PCB pad synchronization, copper routing, DRC and hardware operation are separate.'}
    return report

# 读取输入文件并写出引脚功能核验报告。
def main():
    report = audit()
    (DOC / 'functional-pinout-verification.json').write_text(json.dumps(report, ensure_ascii=False, indent=2) + '\n', encoding='utf8')
    with (DOC / 'functional-pinout.csv').open('w', encoding='utf-8-sig', newline='') as f:
        writer = csv.DictWriter(f, fieldnames=list(report['rows'][0]))
        writer.writeheader()
        writer.writerows(report['rows'])
    print(json.dumps({k: v for k, v in report.items() if k not in {'results', 'rows'}}, ensure_ascii=False, indent=2))
    return 0 if report['pass'] else 1

if __name__ == '__main__':
    raise SystemExit(main())

File Firmware/src/board.c (part):

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/* 读取实物按键并转换为按下掩码。 */
uint8_t board_keys(void)
{
	return (!LL_GPIO_IsInputPinSet(GPIOD, LL_GPIO_PIN_15) << KEY_MODE) |
	       (!LL_GPIO_IsInputPinSet(GPIOA, LL_GPIO_PIN_8) << KEY_NEXT) |
	       (!LL_GPIO_IsInputPinSet(GPIOA, LL_GPIO_PIN_10) << KEY_OK) |
	       (!LL_GPIO_IsInputPinSet(GPIOH, LL_GPIO_PIN_3) << KEY_START);
}

/* 读取灰度输入并按实物左到右的顺序排列。 */
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